# Repository kuro68k/Superplay

File README.md:

# SUPERPLAY

SUPERPLAY is an arcade joystick controller system. It consists of serveral parts.

The main SUPERPLAY PCB is fitted to the joystick and can either connect via USB or a custom KBUS. Both use the same USB cable. Configuration is via a Windows app called SPConfig.

SUPERPLAY supports up to 16 buttons, multiple autofire configurations with selectable fire rate, multiple options for switching modes and rotary joysticks (Seimitsu LS-30, used by SNK) for games like Midnight Resistance. Rotary joystick support is compatible with MAME, and configurable. SUPERPLAY also supports expansion boards via an expansion header, similar to Arduino sheilds.

####True zero lag

Many joystick controllers claim to be zero lag, but as FPS players know USB introduces some delay. USB HID devices are polled at 120Hz maximum, resulting in up to 8ms of lag (1/2 a frame at 60Hz). FPS players hack the Windows mouse driver to increase the poll rate, but it doesn't work for joysticks.

SUPERPLAY uses the excellent vJoy (vjoystick.sourceforge.net) and a custom USB interface to increase the polling rate to 1000Hz, reducing lag down to 1ms maximum. This gives true zero, arcade/console levels of input lag (i.e. none).

####Autofire

SUPERPLAY has a special autofire implementation that allows the player to set a precise frequency, and ensures that a button press is always registered when the button is first pushed. Simple autofire systems switch in a square wave, so the button press is sometimes not registered until the "on" part of the square wave comes around.

####KBUS

Aside from USB, SUPERPLAY can be connected to KBUS devices. Currently under development are a supergun with KBUS support, and a number of "recievers". Recievers connect to games consoles. The first is planned to support Playstation 1/2, Saturn and Dreamcast. Unfortunately due to licencing agreements Dreamcast support will not be published.

KBUS uses a simple 3.3V "RS232" compatible protocol, that can be easily implemented on low cost microcontrollers.

####Other stuff

A HID based USB bootloader will be provided for firmware and configuration updates. See my other projects for code.

The main SUPERPLAY PCB uses an XMEGA 128A3U microcontroller. This might be revised down to a 64KB in future. The project opens with Atmel Studio 6.2. Schematic and gerbers created in Eagle. V1.0 hardware has been built, V1.1 corrects a few issues.

SPConfig is built in Visual Studio 2013 Community Edition. I uses MahApps.Metro to create a "modern" UI.

Everything is licenced under GPL v3.

## KiCad design Joystick/hardware/V2.0/superplay.kicad_pcb

Parts:
C1: 1u; C_0603
C2: 100u; C_1206
C3: 10u; C_0603
C4, C5, C6, C7, C8, C9: 100n; C_0603
C10, C11: 18p; C_0603
D1: LED; LED_0603
J1: AVR-PDI-6A; 3x2_1.27mm_SMD_header
J2: CONN_02X04; Pin_Header_Straight_2x04_Pitch2.54mm
J3: USB_B; USB_Micro-B_Molex_47346-0001
PA1, PA2: CONN_01X05; B5B-ZR-SM4-TF
PB1, PB2, PB3, PB4: CONN_01X05; B5B-ZR-SM4-TF
PJ1: CONN_01X05; B5B-ZR-SM4-TF
PL1: CONN_01X02; B2B-ZR-SM4-TF
PM1: CONN_01X02; B2B-ZR-SM4-TF
PR1, PR2, PR3: CONN_01X05; B5B-ZR-SM4-TF
R1: 680R; R_0603
U1: MCP1700T-3002E; SOT-23
U2: ATXMEGA128A3U-A; TQFP-64_14x14mm_Pitch0.8mm
U3: TPD4S009DBV; SOT-23-6
W1, W2, W3, W4: TEST_1P; MountingHole_3.2mm_M3_Pad
Y1: 16MHz; SMD_Crystal_Multi_QC6CB_7A_ABM7

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, J1.2, J2.3, U1.2 (VO), U2.15 (VCC), U2.25 (VCC), U2.35 (VCC), U2.45 (VCC), U2.53 (VCC), U2.61 (AVCC)
+5V: C1.1, J2.1, J3.1 (VBUS), U1.3 (VI), U3.5 (Vcc)
/A1: PA1.1, U2.31 (PD5/OC1B/XCK1/MOSI)
/A2: PA1.2, U2.30 (PD4/OC1A/~SS~)
/A3: PA1.3, U2.29 (TXD0/OC0D/PD3)
/A4: PA1.4, U2.28 (RXD0/OC0C/PD2)
/A5: PA2.1, U2.39 (PE3/OC0D/TXD0/SCLOUT)
/A6: PA2.2, U2.38 (PE2/OC0C/RXD0/SDAOUT)
/A7: PA2.3, U2.37 (PE1/OC0B/XCK0/SCL/SCLIN)
/A8: PA2.4, U2.36 (PE0/OC0A/SDA/SDAIN)
/B1: PB1.1, U2.13 (TDO/AC0OUT/AC7/ADC7/PB7)
/B2: PB1.2, U2.12 (TCK/AC1OUT/AC6/ADC6/PB6)
/B3: PB1.3, U2.11 (TDI/AC5/ADC5/PB5)
/B4: PB1.4, U2.10 (TMS/AC4/ADC4/PB4)
/B5: PB2.1, U2.9 (DAC1/AC3/ADC3/PB3)
/B6: PB2.2, U2.8 (DAC0/AC2/ADC2/PB2)
/B7: PB2.3, U2.7 (AC1/ADC1/PB1)
/B8: PB2.4, U2.6 (AREFB/AC0/ADC0/PB0)
/B9: PB3.1, U2.5 (AC0OUT/AC7/ADC7/PA7)
/B10: PB3.2, U2.4 (AC1OUT/AC6/ADC6/PA6)
/B11: PB3.3, U2.3 (AC5/ADC5/PA5)
/B12: PB3.4, U2.2 (AC4/ADC4/PA4)
/B13: PB4.1, U2.1 (AC3/ADC3/PA3)
/B14: PB4.2, U2.64 (AC2/ADC2/PA2)
/B15: PB4.3, U2.63 (AC1/ADC1/PA1)
/B16: PB4.4, U2.62 (AREFA/AC0/ADC0/PA0)
/DOWN: PJ1.2, U2.21 (MOSI/XCK1/OC0CHS/OC1B/PC5)
/LED: D1.2 (A), PL1.1, U2.27 (XCK0/OC0B/PD1)
/LEFT: PJ1.3, U2.22 (MISO/RXD1/~OC0DLS~/PC6)
/META: PM1.1, U2.26 (OC0A/PD0)
/R1: PR1.1, U2.43 (PE7/TXD1/SCK/TOSC1)
/R2: PR1.2, U2.42 (PE6/RXD1/MISO/TOSC2)
/R3: PR1.3, U2.41 (PE5/OC1B/XCK1/MOSI)
/R4: PR1.4, U2.40 (PE4/OC1A/~SS~)
/R5: PR2.1, U2.49 (PF3/OC0D/TXD0)
/R6: PR2.2, U2.48 (PF2/OC0C/RXD0)
/R7: PR2.3, U2.47 (PF1/OC0B/XCK0)
/R8: PR2.4, U2.46 (PF0/OC0A)
/R9: PR3.1, U2.55 (PF7)
/R10: PR3.2, U2.54 (PF6)
/R11: PR3.3, U2.51 (PF5)
/R12: PR3.4, U2.50 (PF4)
/RIGHT: PJ1.4, U2.23 (EVOUT/CLKOUT/SCK/TXD1/OC0DHS/PC7)
/UP: PJ1.1, U2.20 (~SS~/~OC0CLS~/OC1A/PC4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.6, J2.5, J2.7, J3.4 (GND), J3.5 (shield), PA1.5, PA2.5, PB1.5, PB2.5, PB3.5, PB4.5, PJ1.5, PL1.2, PM1.2, PR1.5, PR2.5, PR3.5, R1.2, U1.1 (GND), U2.14 (GND), U2.24 (GND), U2.34 (GND), U2.44 (GND), U2.52 (GND), U2.60 (GND), U3.2 (GND), W1.1, W2.1, W3.1, W4.1
unnamed: C10.1, U2.58 (PR0/XTAL2), Y1.1
unnamed: C11.1, U2.59 (PR1/XTAL1), Y1.2
unnamed: D1.1 (K), R1.1
unnamed: J1.1, U2.56 (PDI_DATA)
unnamed: J1.5, U2.57 (~RESET~/PDI_CLK)
unnamed: J2.2, U2.16 (SDAIN/SDA/~OC0ALS~/OC0A/PC0)
unnamed: J2.4, U2.17 (SCLIN/SCL/XCK0/OC0AHS/OC0B/PC1)
unnamed: J2.6, U2.18 (SDAOUT/RXD0/~OC0BLS~/OC0C/PC2)
unnamed: J2.8, U2.19 (SCLOUT/TXD0/OC0BHS/OC0D/PC3)
unnamed: J3.2 (D-), U2.32 (PD6/RXD1/D-/MISO), U3.3 (D2+)
unnamed: J3.3 (D+), U2.33 (PD7/TXD1/D+/SCK/CLKOUT/EVOUT), U3.1 (D1+)

Board: 4 copper layers, 36 parts (15 on the bottom side), 56 nets.

File Joystick/hardware/V2.0/superplay.BOM.txt:

Title:      SUPERPLAY joystick controller
Date:       12/07/2017 11:46:48
Source:     superplay.sch
Revsision:  2.0
Company:    KEIO

No.  Reference             Value            Footprint                       Precision

[ Capacitors, 5 values, X7R/X5R, 16V unless otherwise stated ]
-------------------------------------------------------------------------------------
1    C1                    1u               0603                            
1    C2                    100u             1206                            
1    C3                    10u              0603                            
6    C4, C5, C6, C7, C8    100n             0603                            
     C9
2    C10, C11              18p              0603                            

[ Diodes, 1 value ]
-------------------------------------------------------------------------------------
1    D1                    LED              0603                            

[ Connectors, 3 values ]
-------------------------------------------------------------------------------------
1    J1                    AVR-PDI-6A       3x2_1.27mm_SMD_header           
1    J2                    CONN_02X04       ...r_Straight_2x04_Pitch2.54mm  
1    J3                    USB_B            USB_Micro-B_Molex_47346-0001    

2    PA1, PA2              CONN_01X05       B5B-ZR-SM4-TF                   
4    PB1, PB2, PB3, PB4    CONN_01X05       B5B-ZR-SM4-TF                   
1    PJ1                   CONN_01X05       B5B-ZR-SM4-TF                   
1    PL1                   CONN_01X02       B2B-ZR-SM4-TF                   
1    PM1                   CONN_01X02       B2B-ZR-SM4-TF                   
3    PR1, PR2, PR3         CONN_01X05       B5B-ZR-SM4-TF                   

[ Resistors, 1 value, 1% unless otherwise stated ]
-------------------------------------------------------------------------------------
1    R1                    680R             0603                            

[ Integrated Circuits, 3 values ]
-------------------------------------------------------------------------------------
1    U1                    MCP1700T-3002E   SOT-23                          
1    U2                    ATXMEGA128A3U-A  TQFP-64_14x14mm_Pitch0.8mm      
1    U3                    TPD4S009DBV      SOT-23                          

[ Crystals, 1 value ]
-------------------------------------------------------------------------------------
1    Y1                    16MHz            QC6CB/7A/ABM7 crystals

## KiCad design Hardware/Receiver/ReceiverE5.kicad_pcb

Parts:
C1, C2: 22p; C_0603
C3: 4.7u; C_0603
C4, C5, C10, C11, C12, C13: 100n; C_0603
C6: 680p; C_0603
C7, C9: 10u; C_0603
C8: 10u; C_0805
D1: LED; R_0603
D2: MBR0520LT1G; SOD-123
J1: KBUS; USB_A_multicomp
J2: AVR-PDI-6A; Pin_Header_Straight_2x03
J3: CONN_01X08; Pin_Header_Straight_1x08
J4, J5: CONN_01X06; Pin_Header_Straight_1x06
J6, J7: CONN_01X04; Pin_Header_Straight_1x04
L1: 6.8u; SRN4012TA
R1, R2, R3: 680; R_0603
R4: 47k; R_0603
R5: 15k; R_0603
R6: 2k2; R_0603
R7, R8: 33; R_0603
SW1: SW_SPST; SW_SPST_EVQP7C
U1: ATXMEGA32E5-A; TQFP-32_7x7mm_Pitch0.8mm
U2: LM2731; SOT-23-5
U3, U4: SN74LV07A; SSOP-14
U5: TPS78233; SOT-23-5
U6, U7: 74LVC2T45; VSSOP8_SOT765-1
Y1: Crystal; SMD_Crystal_Multi_QC6CB_7A_ABM7

Connections:
+3V3: C4.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, J2.2, R6.2, U1.17 (VCC), U1.32 (AVCC), U3.14 (Vcc), U4.14 (Vcc), U5.5 (OUT), U6.1 (Vcc(A)), U7.1 (Vcc(A))
+5V: C6.1, C7.1, C8.1, D2.1 (K), J1.1, J7.1, R4.1, U5.1 (IN), U5.3 (EN), U6.8 (Vcc(B)), U7.8 (Vcc(B))
/A0: U1.6 (AREF/AC0/ADC0/PA0), U3.1 (1A)
/A1: U1.5 (AC1/ADC1/PA1), U3.3 (2A)
/A2: U1.4 (DAC0/AC2/ADC2/PA2), U3.5 (3A)
/A3: U1.3 (DAC1/AC3/ADC3/PA3), U3.9 (4A)
/A4: U1.2 (AC4/ADC4/PA4), U3.11 (5A)
/A5: U1.31 (AC5/ADC5/PA5), U3.13 (6A)
/A6: U1.30 (AC1OUT/AC6/ADC6/PA6), U4.1 (1A)
/A7: U1.29 (AC0OUT/AC7/ADC7/PA7), U4.3 (2A)
/BOOST_IN: C3.1, J7.2, L1.1, U2.4 (~SHDN), U2.5 (Vin)
/C0: J3.1, U1.16 (OUT0/IN1/SDA/~OC4ALS~/OC4A/PC0), U4.5 (3A)
/C1: J3.2, U1.15 (IN2/SCL/XCK0/OC4AHS/OC4B/PC1), U4.9 (4A)
/C2: J3.3, U1.14 (IN0/RXD0/~OC4BLS~/OC4C/PC2), U7.2 (1A)
/C3: J3.4, U1.13 (IN3/TXD0/OC4BHS/OC4D/PC3), U4.11 (5A)
/C4: J3.5, U1.12 (EXTCLK/OUT0/IN1/~SS~/OC5A/~OC4CLS~/OC4A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), U6.2 (1A)
/C5: J3.6, U1.11 (IN2/SCK/XCK0/OC5B/OC4CHS/OC4B/PC5), U6.3 (2A)
/C6: J3.7, U1.10 (AC1OUT/IN0/MISO/RXD0/~OC4DLS~/OC4C/PC6), U4.13 (6A)
/C7: J3.8, U1.9 (AC0OUT/IN3/MOSI/TXD0/OC4DHS/OC4D/PC7), U7.3 (2A)
/DIR: U1.21 (PD7/ADC15/TXD0/IN3/CLKOUT/EVOUT/AC0OUT), U6.5 (DIR)
/KBUS_RX: R8.2, U1.26 (PD2/ADC10/RXD0/IN0/OC0)
/KBUS_TX: R7.2, U1.25 (PD3/ADC11/TXD0/IN3/OC1)
/OPT1: R1.1, U1.28 (PD0/ADC8/SDA/IN1/OUT0/AREF)
/OPT2: R2.1, U1.27 (PD1/ADC1/XCK0/SCL/IN2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.4, J1.5, J2.6, J7.3, J7.4, R1.2, R2.2, R5.2, SW1.2, U1.1 (GND), U1.18 (GND), U2.2 (GND), U3.7 (GND), U4.7 (GND), U5.2 (GND), U5.4 (GND), U6.4 (GND), U7.4 (GND), U7.5 (DIR)
unnamed: C1.1, U1.20 (PR0/XTAL2/TOSC2/CLKOUT/EVOUT/RTCOUT/AC1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), Y1.1
unnamed: C2.1, U1.19 (PR1/XTAL1/TOSC1/EXTCLK/AC0OUT), Y1.2
unnamed: C6.2, R4.2, R5.1, U2.3 (FB)
unnamed: D1.1, U1.24 (PD4/ADC12/OC5A/IN1/OUT0/CLKOUT/EVOUT)
unnamed: D1.2, R3.2
unnamed: D2.2 (A), L1.2, U2.1 (SW)
unnamed: J1.2, R7.1
unnamed: J1.3, R8.1
unnamed: J2.1, U1.7 (PDI_DATA)
unnamed: J2.5, U1.8 (~RESET~/PDI_CLK)
unnamed: J4.1, U3.2 (1Y)
unnamed: J4.2, U3.4 (2Y)
unnamed: J4.3, U3.6 (3Y)
unnamed: J4.4, U3.8 (4Y)
unnamed: J4.5, U3.10 (5Y)
unnamed: J4.6, U3.12 (6Y)
unnamed: J5.1, U4.2 (1Y)
unnamed: J5.2, U4.4 (2Y)
unnamed: J5.3, U4.6 (3Y)
unnamed: J5.4, U4.8 (4Y)
unnamed: J5.5, U4.10 (5Y)
unnamed: J5.6, R6.1, U4.12 (6Y)
unnamed: J6.1, U6.7 (1B)
unnamed: J6.2, U6.6 (2B)
unnamed: J6.3, U7.7 (1B)
unnamed: J6.4, U7.6 (2B)
unnamed: R3.1, U1.23 (PD5/ADC13/OC5B/XCK0/IN2)
unnamed: SW1.1, U1.22 (PD6/ADC14/RXD0/IN0/RTCOUT/AC1OUT)

Board: 4 copper layers, 50.0 x 35.5 mm, 40 parts (9 on the bottom side), 53 nets.

## Commit log

2015-08-23 :confetti_ball: Added .gitattributes
2015-08-23 Updated .gitignore
2015-08-23 Added licence
2015-08-25 Added autofire
2015-08-25 Autofire updates
    Added AF toggle mode
    Fixes for AF modes and settings
2015-08-26 Vendor custom interface enabled
    + Vendor interface
2015-08-27 SPFeeder added
    SPFeeder app for vJoy to enable true zero lag
2015-08-27 Vendor USB interface
2015-09-01 KBUS over USB
2015-09-01 KBUS support
2015-09-01 HID descriptor update
    Moved descriptor to separate file, removed POV control
2015-09-02 KBUS over USART
2015-10-13 More flexible config (wip)
    Config made less dependent on hardware
2015-10-14 Compiles (wip)
    Re-worked all config and reporting stuff to at least compile OK
2015-10-14 Generalized config checking
2015-10-14 Fixed physical -> logical mapping
2015-10-15 Enabled rotary inputs for HID again
2015-10-19 Added mapgen
    mapgen tokenizes text files into config data for SUPERPLAY
2015-10-20 Completely free mapping
2015-10-20 Updated mapgen to free mapping support
2015-10-23 Added bootloader
2015-10-26 Fixed EEPROM writing
2015-10-26 Fixed SP_CommonLPM breaking NVM controller
2015-10-27 Added HID support to mapgen
2015-11-01 Fixed default mapping
    Logical map == 0 means end of list
2015-11-01 Fixed and tested bootloader
    Also fixed EEPROM writing and fuses
2015-11-24 Added WCID support
2015-11-24 Updated GUID, clean up
2015-12-03 Reduced watchdog timeout to 128ms
2016-03-11 Feeder now builds
    Added vJoyInterface suff, feeder now builds and runs
2016-04-04 DMA RX for USART
2016-04-15 Fixed a couple of compiler warnings
2016-04-15 Started on AUX button output
2016-04-18 Aux buttons complete, to be tested
2016-05-04 Added Atari/Commodore Receiver
2016-05-16 PSX receiver for E5
2016-07-14 Protocol documentation for KBUS
2016-07-15 Clarified activation timing
2016-07-15 PCE and hardware r2 support
2016-07-18 Improved polling scheme
2016-11-11 Receiver E5 hardware added
2016-11-14 Finished adding footprints
2016-11-14 Removed backup file
2016-11-14 Added optional MISO pull-up
2016-11-14 Fixed a few minor schematic errors
2016-11-14 Changed PDI header to 2.54mm pitch TH
2016-11-14 Started work on PCB layout
2016-11-14 Set up design limits
2016-11-14 Routing try 1
2016-11-14 Routing try 2
2016-11-14 Added mounting holes
2016-11-15 50x30mm layout
2016-11-15 Rounded corners off
2016-11-15 Boost/linear reg
2016-11-15 2 layer power routing try 1
2016-11-15 Added missing series termination resistors for KBUS
2016-11-15 Finished signal routing
2016-11-15 2 layer power routing part 2
2016-11-15 4 layer all routed
    No unrouted nets
2016-11-15 Unconnected net fixed, DRC passes
2016-11-15 Added autosave files to ignore list
2016-11-16 Changed all holes to min 3mm, need to fix DRC errors
2016-11-16 Passed DRC again
2016-11-16 USB connector was on wrong side of the board
2016-11-16 Silk + mounting holes changed to M2.5
2016-11-16 Silkscreen tidied up
2016-11-16 Metadata + PDF schematic
2016-11-16 SVG output + settings
2016-11-17 Laser cut case design
2016-11-18 Added some extra fields for BOM generation with kibom
2016-11-18 Rounded case design
2016-11-22 Added BOM + notes
2016-11-25 Added Ponoko manufacturing files
2017-01-06 Started work on new ConfigGen
2017-01-06 Converted to AS7 project
2017-01-12 Generates binary blobs
2017-01-12 Custom binary field support
2017-01-13 Handles arrays
2017-01-13 Trying to fix array marshalling
2017-01-16 Handles variable length arrays in configs
2017-01-17 HEX file generation working
2017-01-17 Refactored HEX code into class
2017-01-19 Switched to Keio.Utils..dll for text utils and Intel Hex functions
2017-01-19 Removed random firmware dump
2017-01-20 Added CRC32 to config binary output
2017-01-20 Added af_remember_state
2017-01-20 Started adding new configuration format
2017-01-20 Added custom byte stream formatting for padding
2017-01-23 Removed padding
2017-01-23 New config system
2017-01-23 Builds with new config
2017-01-24 New autofire
2017-01-24 AF duty cycle settings
2017-01-24 Updated I/O mapping
2017-01-24 New output mapping
2017-01-25 Enabled output and AF
2017-01-25 Tidied up HID
2017-01-26 KBUS sends long reports
2017-01-26 Set minimum AF frequency
2017-01-26 Migrated to Atmel Studio 7.0
2017-01-26 Start bootloader on software reset instead of EEPROM flag
2017-01-27 eeprom_marker unused
2017-01-27 Best to keep reset flags for application
2017-01-27 Use watchdog to reset out of bootloader
2017-01-27 Corrected bootloader entry logic, added button
2017-01-27 Added optional LED
2017-01-27 Clean up
2017-01-27 Header fixes
2017-01-27 Unused forced mapping
2017-01-27 Config ID registry
2017-01-27 AC config
2017-01-27 Many to one mapping support
2017-01-27 New report format
2017-01-27 Reworking KBUS to not be a state machine
2017-01-29 Fixed flexible length array/sizeof() issue
2017-01-29 HID working, AF broken
2017-01-29 24MHz from PLL/2
2017-01-29 Fixed AF timer calculation
2017-01-29 Autofire fixed
2017-01-29 Better way to calculate struct size
2017-02-02 Replaced state machine
2017-02-02 Fixed input mapper
2017-02-02 New config / mapping
2017-02-03 Atari output enabled
2017-02-03 - redundant clear
2017-02-06 Widened board, added button
2017-02-06 Fixed position of USB
2017-02-07 Cover mapgen
2017-02-08 Version per host
2017-02-08 Top silk
2017-02-08 Bottom silkscreen
2017-02-12 Receiver 2.1 release
2017-02-12 New Playstation receiver
2017-02-12 Removed atari.S from PSX
2017-05-10 Changed programmer
2017-05-10 moved joystick bootloader directory
2017-05-10 moved receiver directories
2017-05-10 removed old mapgen
2017-05-10 Cleaned up receiver hardware directory
2017-05-10 Manufactured releases
2017-05-10 Composite -> HID only USB device
2017-05-10 Removed HID enable/disable feature
2017-05-10 Removed vendor specific protocol
2017-05-10 Formatting
2017-05-10 Fixed descriptor
2017-05-10 Boot to app
2017-05-11 Simplfied entry conditions
2017-05-11 Fixed button entry mechanism
2017-05-11 Enabled bootloader
2017-05-11 Port name typo
2017-05-11 Removed unwanted copy
2017-05-11 Moved expansion port to add I2C
2017-05-11 V2.0 updates
2017-05-11 V2.0 schematic
2017-05-12 Assigned footprints
2017-05-12 Finished foorprint assignments
2017-05-12 Fixed ERCs
2017-05-13 Ignore hex files
2017-05-14 Started PCB layout
2017-05-16 30x50mm board
2017-05-16 Routing attempt
2017-05-17 Rewired to make PCB layout easier
2017-05-17 Routing looks successful
2017-05-17 Routing power
2017-05-18 Routing finished, passes DRC
2017-05-18 Silkscreens
2017-05-18 Silkscreen
2017-05-19 Layer numbers
2017-05-20 Added SUPERPLAY logo
2017-05-20 Keio + graphic
2017-05-20 KEIO logo was backwards
2017-05-20 Gerbers
2017-05-26 Key functionality rework
2017-06-14 Added email
2017-06-16 Output
2017-06-16 V2.0 hardware changes
2017-06-19 V2 hardware and heavy optimization
2017-06-20 USART reports working
2017-06-20 USART mode detection
2017-06-21 Improved USB bus detection
2017-06-21 Old, removed
2017-06-21 Deprecated
2017-06-21 Test config file
2017-06-21 KeioUtils for CLI processing
2017-06-21 Meta keys with debounce
2017-06-21 Port mapping clean-up
2017-06-21 V1/V2 hardware support
2017-07-03 Ported changes from joystick to KBUS
2017-07-03 KBUS changes from joystick
2017-07-03 TX with CRC
2017-07-03 New connection handshake
2017-07-03 Expected response
2017-07-03 USART mode response
2017-07-04 Removed aux, added preamble to RX
2017-07-04 Preamble support
2017-07-04 Enable RX
2017-07-09 Min hole size fixed, drill file for Seeed OK
2017-07-10 Better naming
2017-07-10 32MHz CPU clock, KBUS command code
2017-07-11 Config loading over KBUS
2017-07-11 Fast memory copy/clear functions
2017-07-11 Faster button mapping
2017-07-11 Fixed input mapping
2017-07-11 kbus_matrix now part of input_matrix
2017-07-12 Schematic PDF and BOM refresh
2017-07-12 Added BOM
2017-07-12 Layout overviews
2017-07-12 Updated BOM
2017-09-19 Migrated to 64A3U
2017-09-19 Not needed
2017-09-19 Upgraded to Kicad 4.0.7
2017-10-01 Inverted I/O for more efficient mapping
2017-10-08 Upgraded
2017-10-08 Disabled debug output
2017-10-08 Cleaned up builds
2017-10-08 Bootloader entry
2017-11-04 Testing on hardware V2
2018-04-01 Debugging
2018-04-08 Replaced ASF with new USB stack
2018-06-04 New stack working
2018-06-04 sp_driver duplicated in xmega.h/.S
2018-06-04 unused header
2018-06-04 WCID working
2018-06-04 Removed debug code
2018-08-22 DFU bootloader
2018-08-22 Fixed DFU runtime
2018-08-23 Binary bootloaders
2018-09-02 Button 1 entry condition

Notices in the files:
Hardware/Receiver/ReceiverE5.kicad_pcb:
©2017 Paul Qureshi
Joystick/hardware/V2.0/superplay.kicad_pcb:
© 2017
